# IAR project _ProjectFiles.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8S003
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc\; peripheral; RFM70
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: _ProjectFiles.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp stm8s_it.c
  group peripheral
    peripheral/: peripheral.c peripheral.h
  group RFM70
    RFM70/: rfm70-config.h rfm70.c rfm70.h
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
